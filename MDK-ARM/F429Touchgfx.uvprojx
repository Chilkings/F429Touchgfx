# Keil uVision project F429Touchgfx.uvprojx, settings and files
target F429Touchgfx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F429Touchgfx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ../Drivers/CMSIS/Include;    ../TouchGFX/App;    ../TouchGFX/target/generated;    ../TouchGFX/target;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: F429Touchgfx\F429Touchgfx.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: CTiic.c gt1151q_iic_driver.c delay.c main.c gpio.c freertos.c crc.c dma.c dma2d.c fmc.c ltdc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c w25qxx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/containers/: animationbutton.cpp bottombarcontainer.cpp topbarcontainer.cpp transitionitem.cpp
    ../touchgfx/gui/src/transitions/: covertransition.cpp cubetransition.cpp curtainstransition.cpp fliptransition.cpp rollouttransition.cpp slidetransition.cpp spinouttransition.cpp spintransition.cpp transitions.cpp
    ../touchgfx/gui/src/common/: floateasingequations.cpp frontendapplication.cpp
    ../touchgfx/gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../touchgfx/gui/src/model/: model.cpp
  group generated
    ../touchgfx/generated/gui_generated/src/containers/: animationbuttonbase.cpp bottombarcontainerbase.cpp topbarcontainerbase.cpp transitionitembase.cpp
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_saira_medium_11_4bpp_0.cpp font_saira_medium_20_4bpp_0.cpp font_saira_semibold_30_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_saira_medium_11_4bpp.cpp kerning_saira_medium_20_4bpp.cpp kerning_saira_semibold_30_4bpp.cpp table_saira_medium_11_4bpp.cpp table_saira_medium_20_4bpp.cpp table_saira_semibold_30_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_animationtype.cpp image_background_day.cpp image_background_day_full.cpp image_background_night.cpp image_background_night_full.cpp image_bg_sun.cpp image_chrom-art_off.cpp image_chrom-art_on.cpp image_chrom-art_on_light.cpp image_clouds.cpp image_emptybottombarbg.cpp image_fast.cpp image_icon_info.cpp image_icon_play_dark.cpp image_icon_play_light.cpp image_icon_speed_slider.cpp image_icon_tab_close.cpp image_icon_tab_mini_slider.cpp image_icon_tab_open.cpp image_moon.cpp image_slidemenubutton.cpp image_slow.cpp image_solid_togglr.cpp image_toggle_speed_bg.cpp image_trans_bund_bg.cpp image_trans_bund_gradient_overlay_1.cpp image_trans_bund_gradient_overlay_2.cpp image_trans_bund_tab.cpp image_trans_chrom-art_off.cpp image_trans_chrom-art_on.cpp image_trans_top_bar.cpp image_transitiontype1.cpp image_transitiontype2.cpp image_transitiontype3.cpp image_transitiontype4.cpp image_transitiontype5.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../touchgfx/generated/videos/src/keil/: videos.s
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
software components: CMSIS:CORE 4.3.0
